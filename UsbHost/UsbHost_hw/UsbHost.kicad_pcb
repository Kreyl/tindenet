# Repository Kreyl/tindenet

## KiCad design UsbHost/UsbHost_hw/UsbHost.kicad_pcb

Parts:
ANT1: ANT_PCB_MONO
BLN1: 0896BM15A0001
C2: 1.8pF
C3, C8: 220pF
C4, C6: 10n
C5: 3.3pF
C7, C11: 0.1u
C9, C10: 10pF; CAP_0402
C12: 10u; CAP_0603
C13, C14, C18: 0.1u; CAP_0402
C15: 10n; CAP_0402
C16: 1u; CAP_0402
C17, C20: 20pF; CAP_0603
C19, C21: 1u; CAP_0603
D1, D2: LED
DA1: NCP583SQ
DD1: STM32L151CXTX
DD2: CC1101
L1: 5.6nH; IND_0402
R1: 220R; RES_0603
R2: 56k
R8, R9: 51R; RES_0603
RP1, RP2: REFPOINT
TP1, TP2: TESTPOINT
XL1: ST_SWD
XL2: CONN_3
XL3: USB_A
XTAL1: 27MHz; 03225
XTAL2: 12.0MHz; 0532

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C12.1, C13.1, C14.1, C15.1, C16.1, C18.1, C21.1, DA1.3 (Vout), DD1.1, DD1.9, DD1.24, DD1.36, DD1.48, DD2.4 (DVDD), DD2.9 (AVDD), DD2.11 (AVDD), DD2.14 (AVDD), DD2.15 (AVDD), DD2.18 (DGUARD), XL1.1 (Vdd)
+5V: C19.1, DA1.1 (EN), DA1.4 (Vin), XL3.1 (UVcc)
/CC_CS: DD1.14, DD2.7 (CSn)
/CC_GDO0: DD1.13, DD2.6 (GDO0), TP1.1
/CC_GDO2: DD1.12, DD2.3 (GDO2), TP2.1
/CC_MISO: DD1.16, DD2.2 (SO(GDO1))
/CC_MOSI: DD1.17, DD2.20 (SI)
/CC_SCK: DD1.15, DD2.1 (SCLK)
/LED1: DD1.18, R8.1
/LED2: DD1.19, R9.1
/RF1: BLN1.4 (Bal2), DD2.12 (RF_P)
/RF2: BLN1.3 (Bal1), DD2.13 (RF_N)
/SWCLK: DD1.37, XL1.2 (SWCLK)
/SWDIO: DD1.34, XL1.4 (SWDIO)
/UART_RX: DD1.31, XL2.3
/UART_TX: DD1.30, XL2.2 (PM)
/USB_DM: DD1.32, XL3.2 (D-)
/USB_DP: DD1.33, XL3.3 (D+)
GND: BLN1.2 (GND), BLN1.5 (GND), BLN1.6 (GND), C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.C, D2.C, DA1.2 (GND), DD1.8, DD1.23, DD1.35, DD1.44, DD1.47, DD2.16 (GND), DD2.19 (GND), DD2.PAD (GND), R2.2, XL1.3 (GND), XL2.1, XL3.4 (UGND), XL3.SHLD, XTAL1.H, XTAL2.H
unnamed: ANT1.1, C2.1, L1.1
unnamed: DD2.17 (RBIAS), R2.1
unnamed: BLN1.1 (Unbal), L1.2
unnamed: D2.A, R9.2
unnamed: D1.A, R8.2
unnamed: C17.1, R1.2, XTAL2.2
unnamed: DD1.6, R1.1
unnamed: C20.1, DD1.5, XTAL2.1
unnamed: C11.1, DD2.5 (DCOUPL)
unnamed: C10.1, DD2.10 (XOSC_Q2), XTAL1.2
unnamed: C9.1, DD2.8 (XOSC_Q1), XTAL1.1

Notes on the sheet:
Debug port
Programming
CPU
Indication
Power
Radio
Matching circuit
L-07C5N6SV4
500R07S1R8BV4
3.3V 150mA power regulator
USB

Board: 2 copper layers, 114.0 x 16.0 mm, 41 parts (0 on the bottom side), 30 nets.

## Commit log

2014-11-24 + UsbHost sch and PCB
2014-11-25 + UsbHaost PCB ready and sent to production
2015-01-11 Create project.
2015-01-11 Clocking fron external crystal.
2015-01-12 Import usb part of vcp.
2015-01-12 Replace descriptors files from previous to "bauman_crystal" project. Doesn't testing yet.
2015-01-12 Defining device.
2015-01-12 Descriptors proceed.
2015-01-12 Commit.
2015-01-12 FIX Serial len.
2015-01-14 Not download drivers from the internet automatically.
2015-01-20 ADD: - UsbSerial class with Thread; - Parsing incoming message from host by UsbSerial; - printf(...) in UsbSerial; - add file cmd_list.h
2015-01-21 ADD: - Comand parsing to the HostCommandBuffer; - Event to the main thread if command is correct.
    NEED TO FIX:
    - Usb in transaction doesn't work.
2015-01-30 FIXED: bug with not transmit into usb. Error was in the function CmdRpl, where I'm working in disgusting way with cory args from one function to another.
2015-01-30 ADD: Host/Client support.
2015-02-02 ADD: Radio channel send/receive pkt correctly.
2015-02-03 Start to add acknowledge in radio level.
2015-02-03 Acknowledge working. Should to get correct time delay before ack.
2015-02-03 Correct timings.
2015-02-04 ID reliable command.
2015-02-13 Small refactoring,
2015-03-29 Migrating wiki contents from Google Code
